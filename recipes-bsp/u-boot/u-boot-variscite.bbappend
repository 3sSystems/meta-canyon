FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-u-boot-with-canyon-support-initial-commit.patch \
            file://0001-u-boot-with-canyon-update_1-commit.patch \
            "

